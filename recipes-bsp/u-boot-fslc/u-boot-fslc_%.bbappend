FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI +="file://0001-Set-opos6uldev-U-Boot-env-for-OSTree.patch"

LIC_FILES_CHKSUM = "file://Licenses/README;md5=a2c678cfd4a4d97135585cad908541c6"
